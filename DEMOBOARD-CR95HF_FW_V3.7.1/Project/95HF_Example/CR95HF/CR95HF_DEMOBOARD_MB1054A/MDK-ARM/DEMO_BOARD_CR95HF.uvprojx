# Keil uVision project DEMO_BOARD_CR95HF.uvprojx, settings and files
target DEMO_BOARD_CR95HF (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F103CB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.1.0
  cpu: IROM(0x08000000,0x20000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: DEMO_BOARD_CR95HF +hex
  AfterMake: C:\Keil_v5\ARM\ARMCC\bin\fromelf.exe --bin --output=../Binary/@L.bin !L
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F10X_MD,USE_MB1054_BOARD,CR95HF
  c include: ..\inc;..\..\..\..\..\libraries\95HF\inc;..\..\..\..\..\libraries\USB-FS-Device_Driver\inc;..\..\..\..\..\libraries\USB_Composite\inc;..\..\..\..\..\libraries\USB_MSD\inc;..\..\..\..\..\Utilities\CR95HF_DEMOBOARD_MB1054A\LED\inc;..\..\..\..\..\libraries\CMSIS\CM3\CoreSupport;..\..\..\..\..\libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x;..\..\..\..\..\libraries\STM32F10x_StdPeriph_Driver\inc;..\..\..\..\..\libraries\NDEF\inc
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group User_Appli
    ../src/: main.c hw_config.c stm32f10x_it.c common.c
  group 95HF_Driver
    ../../../../../libraries/95HF/src/: drv_95HF.c drv_spi.c drv_interrupt.c drv_uart.c
  group 95HF_PCD_Libraries
    ../../../../../libraries/95HF/src/: lib_iso7816pcd.c lib_iso14443Apcd.c lib_iso14443Bpcd.c lib_iso15693pcd.c lib_iso18092pcd.c lib_PCD.c
  group 95HF_Manager_Libraries
    ../../../../../libraries/95HF/src/: lib_ConfigManager.c
  group StdPeriph_Driver
    ../../../../../libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_crc.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c
  group User_Drivers
    ../../../../../Utilities/CR95HF_DEMOBOARD_MB1054A/LED/src/: drv_LED.c
  group USB_FS_Driver
    ../../../../../libraries/USB-FS-Device_Driver/src/: usb_core.c usb_init.c usb_int.c usb_mem.c usb_regs.c usb_sil.c
  group USB_Composite
    ../../../../../libraries/USB_Composite/src/: usb_desc.c usb_endp.c usb_hid.c usb_istr.c usb_prop.c usb_pwr.c
  group USB_MSD
    ../../../../../libraries/USB_MSD/src/: mass_mal.c memory.c msd_rw.c nand_if.c scsi_data.c usb_bot.c usb_scsi.c
  group MDK-ARM
    ./: startup_stm32f10x_xl.s
  group CMSIS
    ../../../../../libraries/CMSIS/CM3/CoreSupport/: core_cm3.c
    ../../../../../libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/: system_stm32f10x.c
